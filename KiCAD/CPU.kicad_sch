File: KiCAD/CPU.kicad_sch (KiCad schematic)
At the start: 18 parts

Commit message: Update to V9
Parts:
- renumbered Z24 to Z53
